# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\app;.\hal;.\src;.\sys;.\usbcfg;.\usblib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ./sys/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f10x_hd.s stm32f1_sys.c stm32f1_sys.h stm32f10x.h system_stm32f10x.h
  group src
    ./src/: main.c cmd.c cmd.h main.h queue.c queue.h uart.c uart.h
  group app
    ./app/: key.c key.h led.c led.h
  group usbcfg
    ./usbcfg/: hw_config.c hw_config.h platform_config.h usb_conf.h usb_desc.c usb_desc.h usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group usblib
    ./usblib/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
