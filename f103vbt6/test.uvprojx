# Keil uVision project test.uvprojx, settings and files
target Target 1 (6110000::V6.11::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\app;.\hal;.\src;.\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sys
    ./sys/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f10x_hd.s stm32f1_sys.c stm32f1_sys.h stm32f10x.h
  group src
    ./src/: main.c cmd.c cmd.h main.h queue.c queue.h
  group app
    ./app/: key.c key.h led.c led.h
  group hal
    ./hal/: f1_uart.c f1_uart.h usb_core.c usb_core.h usb_kb_m.c usb_kb_m.h f1_usb.c f1_usb.h
